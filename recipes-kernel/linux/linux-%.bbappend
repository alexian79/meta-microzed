FILESEXTRAPATHS_prepend := "${THISDIR}:"
SRC_URI_append = " file://hw.cfg"
